UBOOT_SOURCE = "git://github.com/xen-troops/u-boot.git;protocol=https;branch=android-master-cockpit-demo-rcar;"
SRCREV = "f9ba26dbad4bda92b02ef8d56ec37dfca5fa4f99"

