FILESEXTRAPATHS_append := "${THISDIR}/files:"

SRC_URI_append = " \
    file://0001-WIP-toolstack-Hotplug-support-for-vcamera.patch \
"
