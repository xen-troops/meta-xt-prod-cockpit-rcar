

SRC_URI = " \
    https://www.riverbankcomputing.com/static/Downloads/PyQtChart/${PV}/PyQtChart-${PV}.tar.gz \
"
SRC_URI[md5sum] = "d5d37bff46b690d6318e5e5f25dd5213"
SRC_URI[sha256sum] = "49960a1483527857b38c1527f9b6328d30bdcc84521f579c0a561a892f54130e"
