inherit nativesdk packagegroup

RDEPENDS:${PN}:remove = " nativesdk-qtdeclarative-tools"
