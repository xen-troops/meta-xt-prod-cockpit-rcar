require qt5-xt-git.inc

SRCREV = "93bdca425bde930d58062216bd3cfae2abdc60c6"

