require qt5-xt-git.inc

SRCREV = "7bf40625ab31685a827f5b6dc13922ae685e8a4f"
