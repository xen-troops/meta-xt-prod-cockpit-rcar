require qt5-xt-git.inc

SRCREV = "bd047261570166b593071212fa4749262e6c5caa"
