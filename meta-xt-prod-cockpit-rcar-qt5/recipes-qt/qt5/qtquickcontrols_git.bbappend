require qt5-xt-git.inc

SRCREV = "e22f5c4cd8ff47545e33a30f7a11d4963979ffb0"
