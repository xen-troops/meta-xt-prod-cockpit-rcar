require qt5-xt-git.inc

SRCREV = "32d7031e87551f29b598e789cfacd275c8095245"

