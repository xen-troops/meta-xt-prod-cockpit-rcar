require qt5-xt-git.inc

SRCREV = "6f5fa73a354d71d4e86c5cc686b0c0f79d4c52a9"

