require qt5-xt-git.inc

QT_MODULE_BRANCH = "2.7"
PV = "2.7.0+git${SRCPV}"
SRCREV:ogl-runtime = "b9b52349d0df29e2eaa30dd13644b9f42d9e4f3e"
