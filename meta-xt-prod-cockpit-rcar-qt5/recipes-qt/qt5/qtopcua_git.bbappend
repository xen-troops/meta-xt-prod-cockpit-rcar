require qt5-xt-git.inc

SRCREV = "f993294b068a70e93b248f556da6ff31245bf2d2"

