require qt5-xt-git.inc

SRCREV = "2cacdd5d5c8feab792126b99d0384092683c551b"
