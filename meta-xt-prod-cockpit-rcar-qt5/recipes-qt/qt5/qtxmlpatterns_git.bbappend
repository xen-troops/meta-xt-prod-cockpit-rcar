require qt5-xt-git.inc

SRCREV = "c4d24e467d7159a43eb90891b954f4cd816ba04b"

