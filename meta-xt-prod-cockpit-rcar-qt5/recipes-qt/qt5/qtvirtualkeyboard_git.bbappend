require qt5-xt-git.inc

SRCREV = "ae04a778c8bafa20812e337fbb80f60b898b8313"

