require qt5-xt-git.inc

SRCREV = "d6148a65aeff1cb2060f0e3e462541bb1ff5219b"
