require qt5-xt-git.inc

SRC_URI_remove = " \
    file://0001-Revert-Get-the-scale-of-the-popup-item-when-setting-.patch \
"

SRCREV = "c0daab494a58ff881afc0252872359e5291a1478"
