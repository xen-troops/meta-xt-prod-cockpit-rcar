require qt5-xt-git.inc


SRCREV_qtquick3d = "c2201f055ed723cf56afd1a7e05e81785b592534"
