require qt5-xt-git.inc

SRCREV_qtlocation = "bae290d25a37fddf88f3a6e2e94c3ee68b2cc038"
SRCREV_qtlocation-mapboxgl = "d7e368c42f2ac7971e81f60b981e566352f1e4fa"

PACKAGECONFIG += "geoservices_mapboxgl" 

