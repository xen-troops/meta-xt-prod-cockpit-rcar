require qt5-xt-git.inc

SRCREV = "289fff1f7f14a7c2dd44ab2232f7a2f17bda5fcf"

