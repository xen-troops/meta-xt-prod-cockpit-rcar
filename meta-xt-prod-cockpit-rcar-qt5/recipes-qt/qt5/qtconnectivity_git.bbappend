require qt5-xt-git.inc

SRCREV = "6fe502ad842c322981b45632e4f59182be1908d2"
