require qt5-xt-git.inc

SRCREV = "0da764d8fec459ee28b70f68028ada81ed31abf7"

