require qt5-xt-git.inc

SRCREV = "73d9affb0c44dc21d83e9aeec5e4d83bc57d189b"

