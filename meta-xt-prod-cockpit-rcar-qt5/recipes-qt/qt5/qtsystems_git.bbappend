require qt5-xt-git.inc
