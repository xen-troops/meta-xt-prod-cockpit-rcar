SRC_URI += " \
    file://0001-missing-qpainterpath.h-include-added-needed-with-Qt-.patch \
"

SRC_URI[qwt.md5sum] = "4fb1852f694420e3ab9c583526edecc5"
SRC_URI[qwt.sha256sum] = "1529215329e51fc562e0009505a838f427919a18b362afff441f035b2d9b5bd9"

