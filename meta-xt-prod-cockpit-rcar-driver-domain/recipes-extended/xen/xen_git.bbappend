FILESEXTRAPATHS:append := "${THISDIR}/files:"

SRC_URI:append = " \
    file://0001-xen-HACK-disable-warning-delay.patch \
"
