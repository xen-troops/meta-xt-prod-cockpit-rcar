LIC_FILES_CHKSUM = " \
    file://GPL-COPYING;md5=60422928ba677faaa13d6ab5f5baaa1e \
    file://MIT-COPYING;md5=8c2810fa6bfdc5ae5c15a0c1ade34054 \
"
PVRKM_BRANCH = "1.11/5516664_5.1.0"
PVRKM_SRCREV = "6994a4be87075975665fcef1fd95c087b0a007c8"
