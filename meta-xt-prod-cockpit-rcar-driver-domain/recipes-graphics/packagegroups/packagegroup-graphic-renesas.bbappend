RDEPENDS:packagegroup-graphics-renesas-wayland:remove = " \
    wayland-wsegl \
"
