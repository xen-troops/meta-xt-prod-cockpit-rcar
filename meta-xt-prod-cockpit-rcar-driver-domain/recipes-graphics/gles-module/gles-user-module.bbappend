FILES:${PN}:remove = " \
    /lib/firmware/rgx.sh* \
"
