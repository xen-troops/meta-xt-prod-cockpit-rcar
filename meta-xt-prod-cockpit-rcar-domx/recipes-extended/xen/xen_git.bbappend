FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
require xen.inc
