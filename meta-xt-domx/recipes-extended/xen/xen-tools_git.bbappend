FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI:append = " \
	file://0001-foreign-memory-fix-build-errors.patch \
"
